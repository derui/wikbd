File: middle_l/middle_l.kicad_pcb (KiCad board)
At the start: 2 copper layers, 128.5 x 102.6 mm, 0 parts

Commit message: feat: update layout
Other:
- board size 128.5 x 102.6 mm -> 130.1 x 102.9 mm
